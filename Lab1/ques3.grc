options:
  parameters:
    generate_options: qt_gui
    id: top_block
    output_language: python
    title: top_block
  states: {}

blocks:
- name: a1
  id: variable_qtgui_range
  parameters:
    label: band1
    start: '0'
    step: '1'
    stop: '10'
    value: '1'
  states: {}
- name: a2
  id: variable_qtgui_range
  parameters:
    label: band2
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: a3
  id: variable_qtgui_range
  parameters:
    label: band3
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: a4
  id: variable_qtgui_range
  parameters:
    label: bannd4
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: a5
  id: variable_qtgui_range
  parameters:
    label: band5
    start: '0'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: audio_sink_1
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {state: disabled}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: a1
    high_cutoff_freq: '500'
    low_cutoff_freq: '20'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '10'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: a2
    high_cutoff_freq: '3000'
    low_cutoff_freq: '500'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '50'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: a3
    high_cutoff_freq: '6000'
    low_cutoff_freq: '3000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: a4
    high_cutoff_freq: '9000'
    low_cutoff_freq: '6000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: a5
    high_cutoff_freq: '15000'
    low_cutoff_freq: '9000'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0_0_0_0_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '15000'
    low_cutoff_freq: '14999'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a5
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a4
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a3
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a2
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: a1
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: a5
    type: float
  states: {state: disabled}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/nimayshah/Downloads/Bach.wav
    repeat: 'True'
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_add_xx_0, '0']
- [band_pass_filter_0, '0', blocks_multiply_const_vxx_0_0_0_0_0, '0']
- [band_pass_filter_0_0, '0', blocks_add_xx_0, '1']
- [band_pass_filter_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [band_pass_filter_0_0_0, '0', blocks_add_xx_0, '2']
- [band_pass_filter_0_0_0, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [band_pass_filter_0_0_0_0, '0', blocks_add_xx_0, '3']
- [band_pass_filter_0_0_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [band_pass_filter_0_0_0_0_0, '0', blocks_add_xx_0, '4']
- [band_pass_filter_0_0_0_0_0, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_0_0_0_0_0_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_add_xx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '4']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '3']
- [blocks_multiply_const_vxx_0_0_0, '0', blocks_add_xx_0, '2']
- [blocks_multiply_const_vxx_0_0_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0_0_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0_1, '0', audio_sink_1, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0_0_0_0, '0']
- [blocks_throttle2_0, '0', band_pass_filter_0_0_0_0_0_0, '0']
- [blocks_wavfile_source_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
