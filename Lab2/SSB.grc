options:
  parameters:
    generate_options: qt_gui
    id: SSB
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '500000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '-1'
    freq: '200000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: analog_sig_source_x_2_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_2_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/nimayshah/Downloads/vocal.wav
    repeat: 'False'
  states: {state: disabled}
- name: blocks_wavfile_source_1
  id: blocks_wavfile_source
  parameters:
    file: /home/nimayshah/Downloads/background.wav
    repeat: 'True'
  states: {state: disabled}
- name: blocks_wavfile_source_2
  id: blocks_wavfile_source
  parameters:
    file: /home/nimayshah/Downloads/vocal(1).wav
    repeat: 'True'
  states: {}
- name: hilbert_fc_0
  id: hilbert_fc
  parameters:
    num_taps: '65'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    decim: '1'
    gain: '2'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@2
    type: float
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@5
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@3
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '300000'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '44100'
    interp: '300000'
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: '32000'
    interp: '500000'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: message
    label1: mod
    label2: mod_f
    label3: demod
    label4: demod_f
    label5: m2_demod_f
    num_tabs: '6'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_1, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_2_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_2_0, '0', qtgui_time_sink_x_0, '0']
- [analog_sig_source_x_2_0_0, '0', hilbert_fc_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_0_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_xx_0_1, '1']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_imag_0, '0', blocks_multiply_xx_0_0, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_0_1, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_wavfile_source_1, '0', rational_resampler_xxx_1, '0']
- [blocks_wavfile_source_2, '0', rational_resampler_xxx_2, '0']
- [hilbert_fc_0, '0', blocks_complex_to_imag_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [low_pass_filter_0_0, '0', qtgui_freq_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_multiply_xx_0_0, '1']
- [rational_resampler_xxx_2, '0', blocks_multiply_xx_0, '0']
- [rational_resampler_xxx_2, '0', hilbert_fc_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
