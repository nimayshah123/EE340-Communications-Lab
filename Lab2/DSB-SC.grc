options:
  parameters:
    generate_options: qt_gui
    id: DSBSC
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '300000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '10000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {state: disabled}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: samp_rate
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: /home/nimayshah/Downloads/vocal(1).wav
    repeat: 'True'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '20000'
    gain: '2'
    interp: '1'
    samp_rate: samp_rate
    type: interp_fir_filter_fff
    width: '100'
    win: window.WIN_RECTANGULAR
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    type: float
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@1
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@0
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '32'
    interp: '300'
    type: fff
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: Mod
    label1: Mod_f
    label2: Demod
    label3: Demod_f
    num_tabs: '4'
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_1_0, '0', blocks_multiply_xx_1, '1']
- [blocks_multiply_xx_0, '0', blocks_multiply_xx_1, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_1, '0', low_pass_filter_0, '0']
- [blocks_wavfile_source_0, '0', rational_resampler_xxx_0, '0']
- [low_pass_filter_0, '0', audio_sink_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', qtgui_time_sink_x_1, '0']
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
