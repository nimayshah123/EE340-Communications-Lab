options:
  parameters:
    generate_options: qt_gui
    id: task_3
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: algo
  id: variable_adaptive_algorithm
  parameters:
    cons: constell
    modulus: '1'
    step_size: '.1'
    type: cma
  states: {}
- name: alpha
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.1'
    stop: '1'
    value: '1'
  states: {}
- name: constell
  id: variable_constellation
  parameters:
    const_points: '[1+0j,0.707+0.707j,-0.707+0.707j,1j,-1,-0.707-0.707j,0.707-0.707j,-1j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2, 4, 5, 7, 6]'
    type: calcdist
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    label: Delay
    rangeType: int
    start: '0'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: eq_1
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '-0.5'
  states: {}
- name: eq_2
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0.25'
  states: {}
- name: eq_3
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '-0.125'
  states: {}
- name: eq_4
  id: variable_qtgui_range
  parameters:
    start: '-1'
    step: '0.1'
    stop: '1'
    value: '0.0625'
  states: {}
- name: num
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '10'
    value: '3'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '20000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: '0'
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: float
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '100000'
    offset: '0'
    phase: '0'
    samp_rate: '400000'
    type: float
    waveform: analog.GR_SIN_WAVE
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: blocks_add_xx_3
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_imag_1
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '40'
    type: float
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    delay: '40'
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_0
  id: blocks_delay
  parameters:
    delay: '80'
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_0_0
  id: blocks_delay
  parameters:
    delay: '120'
    type: complex
  states: {state: disabled}
- name: blocks_delay_1_0_0_0
  id: blocks_delay
  parameters:
    delay: '160'
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/nimay/Desktop/Lab_7/OUTPUT.txt
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/nimay/Desktop/Lab_6/Original_Text.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: eq_1
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1
  id: blocks_multiply_const_vxx
  parameters:
    const: eq_2
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: eq_3
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_1_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: eq_4
    type: complex
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: blocks_pack_k_bits_bb_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: num
    type: byte
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_unpack_k_bits_bb_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '3'
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1+0j,0.707+0.707j,-0.707+0.707j,1j,-1,-0.707-0.707j,0.707-0.707j,-1j]'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constell
  states: {}
- name: digital_linear_equalizer_0
  id: digital_linear_equalizer
  parameters:
    alg: algo
    num_taps: '4'
    sps: '1'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '8'
    taps: '1'
    type: ccc
  states: {}
- name: interp_fir_filter_xxx_0
  id: interp_fir_filter_xxx
  parameters:
    interp: '8'
    taps: '1'
    type: ccc
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '50000'
    decim: '1'
    gain: '1'
    samp_rate: '400000'
    type: fir_filter_fff
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@3
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@2
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: tab@5
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.05'
    bw: '400000'
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@4
    type: float
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@0
    type: complex
  states: {}
- name: qtgui_freq_sink_x_3
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: tab@3
    type: complex
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@1
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab@3
    size: '1024'
    srate: samp_rate
    stemplot: 'True'
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '5'
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '5'
    interp: '1'
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '3'
    ntaps: 11*8
    samp_rate: '80000'
    sym_rate: '10000'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: alpha
    decim: '1'
    gain: '5.5'
    ntaps: 11*8
    samp_rate: '80000'
    sym_rate: '10000'
    type: fir_filter_ccf
  states: {}
- name: tab
  id: qtgui_tab_widget
  parameters:
    label0: chunks_symb_t
    label1: chunks_symb_f
    label2: rrc_in
    label3: rrc_out
    label4: passband
    label5: const_out
    label6: error
    num_tabs: '7'
  states: {}

connections:
- [analog_noise_source_x_0, '0', blocks_add_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0, '0']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_2, '1']
- [blocks_add_xx_0, '0', blocks_delay_0, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_add_xx_1, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_2, '0', blocks_multiply_xx_0_0, '1']
- [blocks_add_xx_2, '0', blocks_multiply_xx_0_0_0, '1']
- [blocks_add_xx_3, '0', rational_resampler_xxx_1, '0']
- [blocks_complex_to_imag_1, '0', blocks_multiply_xx_2, '0']
- [blocks_complex_to_real_2, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_1_0, '0']
- [blocks_delay_1, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_delay_1_0, '0', blocks_multiply_const_vxx_0_1, '0']
- [blocks_delay_1_0_0, '0', blocks_multiply_const_vxx_0_1_0, '0']
- [blocks_delay_1_0_0_0, '0', blocks_multiply_const_vxx_0_1_0_0, '0']
- [blocks_file_source_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_1, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_1_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_1_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_delay_1_0_0_0, '0']
- [blocks_float_to_complex_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_3, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_3, '1']
- [blocks_multiply_const_vxx_0_1, '0', blocks_add_xx_3, '2']
- [blocks_multiply_const_vxx_0_1_0, '0', blocks_add_xx_3, '3']
- [blocks_multiply_const_vxx_0_1_0_0, '0', blocks_add_xx_3, '4']
- [blocks_multiply_const_vxx_1, '0', blocks_add_xx_2, '0']
- [blocks_multiply_const_vxx_1_0, '0', blocks_add_xx_2, '1']
- [blocks_multiply_xx_0, '0', blocks_add_xx_1, '0']
- [blocks_multiply_xx_0_0, '0', low_pass_filter_0, '0']
- [blocks_multiply_xx_0_0_0, '0', low_pass_filter_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_add_xx_1, '1']
- [blocks_pack_k_bits_bb_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_pack_k_bits_bb_1, '0', blocks_file_sink_0, '0']
- [blocks_skiphead_0, '0', blocks_unpack_k_bits_bb_1, '0']
- [blocks_unpack_k_bits_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_unpack_k_bits_bb_1, '0', blocks_pack_k_bits_bb_1, '0']
- [digital_chunks_to_symbols_xx_0, '0', interp_fir_filter_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_freq_sink_x_2, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_skiphead_0, '0']
- [digital_linear_equalizer_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_linear_equalizer_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [fir_filter_xxx_0, '0', digital_linear_equalizer_0, '0']
- [interp_fir_filter_xxx_0, '0', root_raised_cosine_filter_0, '0']
- [low_pass_filter_0, '0', blocks_float_to_complex_0, '0']
- [low_pass_filter_0_0, '0', blocks_float_to_complex_0, '1']
- [rational_resampler_xxx_0, '0', blocks_complex_to_imag_1, '0']
- [rational_resampler_xxx_0, '0', blocks_complex_to_real_2, '0']
- [rational_resampler_xxx_1, '0', root_raised_cosine_filter_0_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_const_sink_x_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_3, '0']
- [root_raised_cosine_filter_0, '0', qtgui_time_sink_x_2, '0']
- [root_raised_cosine_filter_0, '0', rational_resampler_xxx_0, '0']
- [root_raised_cosine_filter_0_0, '0', fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
